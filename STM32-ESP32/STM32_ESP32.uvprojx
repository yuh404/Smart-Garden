# Keil uVision project STM32_ESP32.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_ESP32
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=3
  c define: IP=IPR
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32_ESP32.h STM32_ESP32.c STM32_ESP32_MAIN.c setting.h setting.c SYSCLK.c SYSCLK.h UART_CONFIG.c UART_CONFIG.h NVIC.h NVIC.c systick.h systick.c dien_dung.c dien_dung.h BH1750.h BH1750.c HDC_1018.h HDC_1018.c HCSR04.h HCSR04.c
    C:/Users/vanhu/Downloads/stsw-stm32054_v3-6-0/STM32F10x_StdPeriph_Lib_V3.6.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c
software components: CMSIS:CORE 6.1.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
